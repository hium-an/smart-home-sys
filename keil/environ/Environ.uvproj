# Keil uVision project Environ.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Environ +hex
  c flags: Optimize=8
  c define: PROJ_MCU3
  c include: ../../inc
  group Source Group 1
    ../../src/: main2.c sensor.c uart.c
