# Keil uVision project Door.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Door +hex
  c flags: Optimize=8
  c define: PROJ_MCU2
  c include: ../../inc
  group Source Group 1
    ../../src/: door.c main_door.c sound.c uart.c
