# Keil uVision project Security.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Security +hex
  c flags: Optimize=8
  c define: PROJ_MCU1
  c include: ../../inc
  group Source Group 1
    ../../src/: lcd.c main1.c security.c
